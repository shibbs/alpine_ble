# Keil uVision project ble_app_michron.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_template +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x24000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../localLibs/: app_state_machine.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/app_common/: pstorage.c crc16.c app_scheduler.c app_timer.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
  group SM_and_Includes
    ../localLibs/: app_state_machine.h alpine_tl_state_machine.h alpine_boards.h alpine_includes.h alpine_tl_state_machine.c alpine_boards.c
  group Utilities
    ../localLibs/: radian_stepper.h radian_stepper.c
    ../Simple_PWM/: nrf_pwm.c nrf_pwm.h
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: ble_app_template +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
